# Keil uVision project project.uvprojx, settings and files
target Target_1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: project +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_STDPERIPH_DRIVER,SYS_SUPPORT_OS
  c include: ..\CMSIS;..\User;..\Firmware\inc;..\Middleware\FreeRTOS\portable\ARM_CM3;..\Middleware\FreeRTOS\include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group CMSIS
    ../CMSIS/: core_cm3.c system_stm32f10x.c startup_stm32f10x_md.s
  group Firmware
    ../Firmware/src/: misc.c stm32f10x_usart.c stm32f10x_gpio.c stm32f10x_exti.c stm32f10x_rcc.c
  group Middleware/FreeRTOS
    ../Middleware/FreeRTOS/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middleware/FreeRTOS/portable/MemMang/: heap_4.c
    ../Middleware/FreeRTOS/portable/ARM_CM3/: port.c
  group User
    ../User/: main.c systick.c stm32f10x_conf.h FreeRTOSConfig.h stm32f10x_it.c
